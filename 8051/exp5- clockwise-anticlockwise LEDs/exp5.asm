        ORG 0000H
		
MAIN:	MOV A,#01H
		JB P2.0,CLOCKWISE
		JB P2.1,ANTICLOCKWISE

CLOCKWISE:	
		MOV P0,A
		ACALL DELAY
		RL A
		JMP CLOCKWISE
		
ANTICLOCKWISE:
		MOV P0,A
		ACALL DELAY
		RR A
		JMP ANTICLOCKWISE
		
DELAY:	MOV R2,#14H
L1: 	MOV TMOD,#10H
		MOV TH1,#4BH
		MOV TL1,#0FDH
		SETB TR1
L2:		JNB TF1,L2
		CLR TR1
		CLR TF1
		DJNZ R2,L1
		RET
		
		END