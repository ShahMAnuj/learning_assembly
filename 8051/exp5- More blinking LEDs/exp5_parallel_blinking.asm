		ORG 0000H
	
		SETB P2.0	
MAIN:	JNB P2.0,L1
		MOV P0,#0FFH
		MOV R0,#33H
		MOV R1,#0FFH
		ACALL DELAY
		MOV P0,#00H
		ACALL DELAY
		JMP MAIN

L1:		MOV P0,#0FFH
		MOV R0,#19H
		MOV R1,#0FFH
		ACALL DELAY
		MOV P0,#00H
		ACALL DELAY
		JMP MAIN

;FF33 for 0.5ms
;FF1A for 0.25ms

DELAY:	MOV TMOD,01H
		MOV TLO,R0
		MOV THO,R1
		SETB TR0
HERE:	JNB TF0,HERE
		CLR TR0
		CLR TF0
		RET